# IAR project ACU_Bootloader.ewp, settings and files
configuration ACU_Bootloader_CM4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32H745XI_CM4 ST STM32H745XI_CM4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32H745xx; USE_PWR_DIRECT_SMPS_SUPPLY
  ICCARM.CCIncludePath2: ../CM4/LWIP/App; ../CM4/LWIP/Target; ../CM4/Core/Inc; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/compat/posix; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/net; ../Middlewares/Third_Party/LwIP/src/include/compat/posix/sys; ../Middlewares/Third_Party/LwIP/src/include/compat/stdc; ../Middlewares/Third_Party/LwIP/system/arch; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ACU_Bootloader_CM4.hex
  ILINK.IlinkOutputFile: ACU_Bootloader_CM4.out
  ILINK.IlinkIcfFile: stm32h745xx_flash_CM4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ACU_Bootloader_CM7 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32H745XI_CM7 ST STM32H745XI_CM7
  ICCARM.CCDefines: CORE_CM7; USE_HAL_DRIVER; STM32H745xx; USE_PWR_DIRECT_SMPS_SUPPLY
  ICCARM.CCIncludePath2: ../CM7/Core/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  OBJCOPY.OOCOutputFile: ACU_Bootloader_CM7.hex
  ILINK.IlinkOutputFile: ACU_Bootloader_CM7.out
  ILINK.IlinkIcfFile: stm32h745xx_flash_CM7.icf
  group Application/EWARM
    ./: startup_stm32h745xx_CM4.s startup_stm32h745xx_CM7.s
  group Application/User/CM4/LWIP/App
    ../CM4/LWIP/App/: lwip.c
  group Application/User/CM4/LWIP/Target
    ../CM4/LWIP/Target/: ethernetif.c eth_custom_phy_interface.c
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/CM7/Core
    ../CM7/Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c
  group Drivers/CMSIS
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    ../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Middlewares/Third_Party/LwIP/src/api/: sockets.c if_api.c netdb.c tcpip.c err.c netifapi.c api_lib.c api_msg.c netbuf.c
    ../Middlewares/Third_Party/LwIP/src/core/: memp.c sys.c inet_chksum.c raw.c tcp_out.c ip.c dns.c init.c mem.c altcp_alloc.c def.c udp.c stats.c tcp_in.c netif.c altcp_tcp.c tcp.c pbuf.c timeouts.c altcp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c acd.c igmp.c etharp.c icmp.c ip4.c ip4_frag.c ip4_addr.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6.c icmp6.c mld6.c dhcp6.c ethip6.c nd6.c inet6.c ip6_addr.c ip6_frag.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
    ../Middlewares/Third_Party/LwIP/src/apps/tftp/: tftp.c
